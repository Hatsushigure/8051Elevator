# Keil uVision project Elevator.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Elevator +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c display.c initialize.c keyboard.c NumberInput.c Joystick.c ElevatorControl.c LcdDisplay.c
